options:
  parameters:
    author: JACON clinic team
    description: PlutoSDR TX source for bench-testing the JACON delay-line frequency discriminator (1.0-1.2 GHz)
    generate_options: qt_gui
    id: jacon_pluto_discriminator_tx
    output_language: python
    title: JACON - Pluto TX for the delay-line discriminator test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
    comment: Pluto baseband rate (keep >= 2.084 MSPS)
  states: {}
- name: tone_offset
  id: variable
  parameters:
    value: 200e3
    comment: tone sits this far above the Pluto LO (keeps LO leakage off the wanted tone)
  states: {}
- name: amp
  id: variable
  parameters:
    value: '0.9'
    comment: digital amplitude (<1)
  states: {}
- name: f_tx
  id: variable
  parameters:
    value: f_manual
    comment: actual RF frequency; the sweep thread overrides it in mode 1
  states: {}
- name: sweep_start
  id: variable
  parameters:
    value: 1.0e9
    comment: mode 1 sweep start (Hz)
  states: {}
- name: sweep_stop
  id: variable
  parameters:
    value: 1.2e9
    comment: mode 1 sweep stop (Hz)
  states: {}
- name: sweep_step
  id: variable
  parameters:
    value: 5e6
    comment: mode 1 sweep step (Hz)
  states: {}
- name: dwell_s
  id: variable
  parameters:
    value: '2.0'
    comment: mode 1 dwell per step (s) - long enough to read your meter/scope
  states: {}
- name: pulse_on_ms
  id: variable
  parameters:
    value: '1.0'
    comment: mode 2 pulse width (ms)
  states: {}
- name: pulse_period_ms
  id: variable
  parameters:
    value: '10.0'
    comment: mode 2 pulse period (ms)
  states: {}
- name: f_manual
  id: variable_qtgui_range
  parameters:
    label: TX RF frequency (Hz)
    value: 1.1e9
    start: 1.0e9
    stop: 1.2e9
    step: 1e6
    gui_hint: 0,0,1,2
  states: {}
- name: atten
  id: variable_qtgui_range
  parameters:
    label: Pluto TX attenuation (dB)
    value: '10'
    start: '0'
    stop: '89.75'
    step: '0.25'
    gui_hint: 1,1,1,1
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    label: Mode
    type: int
    num_opts: '3'
    value: '0'
    option0: '0'
    label0: Manual CW
    option1: '1'
    label1: Auto stepped sweep (CSV log)
    option2: '2'
    label2: Pulsed CW (radar-like gate)
    gui_hint: 1,0,1,1
  states: {}
- name: f_label
  id: variable_qtgui_label
  parameters:
    label: Transmitting (MHz)
    type: real
    value: f_tx/1e6
    gui_hint: 2,0,1,2
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    type: complex
    waveform: analog.GR_COS_WAVE
    samp_rate: samp_rate
    freq: tone_offset
    amp: amp
    offset: '0'
    phase: '0'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: '[1.0+0j]*int(samp_rate*pulse_on_ms/1e3) + [0j]*int(samp_rate*(pulse_period_ms-pulse_on_ms)/1e3)'
    repeat: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: 1.0 if mode == 2 else 0.0
    comment: gate used only in pulsed mode
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    type: complex
    const: 0.0 if mode == 2 else 1.0
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    type: fc32
    frequency: int(f_tx - tone_offset)
    samplerate: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    attenuation1: atten
    filter_source: '''Auto'''
    bandwidth: '20000000'
    comment: uri empty = first Pluto on USB; or ip:192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"Baseband sent to Pluto (0 Hz = Pluto LO, tone sits at +tone_offset)"'
    fftsize: '2048'
    fc: '0'
    bw: samp_rate
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: '""'
    color1: blue
  states: {}
- name: snippet_sweep
  id: snippet
  parameters:
    section: main_after_start
    code: |-
      import threading, time, csv, os, datetime

      def _jacon_worker(tb):
          try:
              log_dir = os.path.dirname(os.path.abspath(__file__))
          except NameError:
              log_dir = os.getcwd()
          fname = os.path.join(log_dir, "tx_log_" + datetime.datetime.now().strftime("%Y%m%d_%H%M%S") + ".csv")
          print("[JACON] logging TX settings to", fname, flush=True)
          with open(fname, "w", newline="") as fh:
              w = csv.writer(fh)
              w.writerow(["unix_time_s", "mode", "tx_freq_hz", "pluto_lo_hz", "atten_db", "sweep_step_index"])
              last = None
              idx = 0
              while True:
                  if tb.mode == 1:
                      n = int(round((tb.sweep_stop - tb.sweep_start) / tb.sweep_step)) + 1
                      k = idx % n
                      f = tb.sweep_start + k * tb.sweep_step
                      tb.set_f_tx(f)
                      w.writerow(["%.3f" % time.time(), 1, "%.0f" % f, "%.0f" % (f - tb.tone_offset), tb.atten, k])
                      fh.flush()
                      print("[JACON] sweep step %d/%d  %.3f MHz  (dwell %.1f s)" % (k + 1, n, f / 1e6, tb.dwell_s), flush=True)
                      idx += 1
                      time.sleep(tb.dwell_s)
                  else:
                      idx = 0
                      if tb.f_tx != tb.f_manual:
                          tb.set_f_tx(tb.f_manual)
                      state = (tb.mode, tb.f_tx, tb.atten)
                      if state != last:
                          w.writerow(["%.3f" % time.time(), tb.mode, "%.0f" % tb.f_tx, "%.0f" % (tb.f_tx - tb.tone_offset), tb.atten, ""])
                          fh.flush()
                          last = state
                      time.sleep(0.2)

      self._jacon_thread = threading.Thread(target=_jacon_worker, args=(self,), daemon=True)
      self._jacon_thread.start()
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
