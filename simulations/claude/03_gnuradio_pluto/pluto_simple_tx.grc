options:
  parameters:
    author: JACON clinic team
    description: Pluto CW transmitter (frequency + power) with RX monitor and TX/RX time + frequency plots
    generate_options: qt_gui
    id: pluto_simple_tx
    output_language: python
    title: Pluto simple CW TX + RX monitor
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: TX frequency (Hz)
    start: 325e6
    step: 1e6
    stop: 3.8e9
    value: 1.2e9
  states: {}
- name: p_dbm
  id: variable_qtgui_range
  parameters:
    comment: requested output power; only as accurate as p_max_dbm
    gui_hint: 1,0,1,1
    label: TX power (dBm, approx - calibrate p_max_dbm)
    start: p_max_dbm - 89.75
    step: '0.25'
    stop: p_max_dbm
    value: p_max_dbm - 10
  states: {}
- name: p_max_dbm
  id: variable
  parameters:
    comment: 'CALIBRATE: power measured at 0 dB attenuation at your frequency (Pluto ~0..+7 dBm, frequency dependent)'
    value: '5.0'
  states: {}
- name: pluto_uri
  id: variable
  parameters:
    comment: network address over the Pluto's USB-Ethernet gadget; lets TX and RX blocks share one Pluto
    value: '''ip:192.168.2.1'''
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: RX gain (dB, manual)
    start: '0'
    step: '1'
    stop: '73'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 'BASEBAND rate: plots cover freq +/- samp_rate/2. The Pluto does the GHz mixing, so this is NOT 2x the RF'
    value: 2.4e6
  states: {}
- name: tone_offset
  id: variable
  parameters:
    comment: baseband sine frequency (keep << samp_rate/2); Pluto LO = freq - tone_offset so the RF tone lands exactly on freq. Do NOT put the RF frequency here
    value: 50e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.7'
    comment: complex sine at +tone_offset -> single RF tone at freq
    freq: tone_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: min(89.75, max(0.0, p_max_dbm - p_dbm))
    bandwidth: '20000000'
    buffer_size: '32768'
    comment: attenuation = p_max_dbm - p_dbm
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq - tone_offset)
    samplerate: int(samp_rate)
    type: fc32
    uri: pluto_uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: loop TX -> attenuator (>=30 dB) -> RX to see the real output
    filter_source: '''Auto'''
    frequency: int(freq - tone_offset)
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: pluto_uri
  states: {}
- name: qtgui_freq_sink_rx
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq - tone_offset
    fftsize: '4096'
    grid: 'True'
    gui_hint: 3,0,1,1
    label1: '""'
    name: '"RX (spectrum, RF axis)"'
    type: complex
    update_time: '0.20'
  states: {}
- name: qtgui_freq_sink_tx
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq - tone_offset
    fftsize: '4096'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: '""'
    name: '"TX baseband -> Pluto (spectrum, RF axis)"'
    type: complex
    update_time: '0.20'
  states: {}
- name: qtgui_time_sink_rx
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 3,1,1,1
    label1: I (real)
    label2: Q (imag)
    name: '"RX (I/Q vs time)"'
    size: '256'
    srate: samp_rate
    type: complex
    update_time: '0.20'
  states: {}
- name: qtgui_time_sink_tx
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: I (real)
    label2: Q (imag)
    name: '"TX baseband -> Pluto (I/Q vs time)"'
    size: '256'
    srate: samp_rate
    type: complex
    update_time: '0.20'
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_tx, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_tx, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_rx, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_rx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
